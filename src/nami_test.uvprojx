# Keil uVision project nami_test.uvprojx, settings and files
target MDR1986BE92 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nami_test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\MDR1986BE92\inc;.\MDR1986BE92\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group target
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: startup_MDR32F9Qx.s system_MDR32F9Qx.c
  group drivers
    ./Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_bkp.c MDR32F9Qx_dma.c MDR32F9Qx_eeprom.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c
  group src
    ./MDR1986BE92/src/: Main.c MDR32F9Qx_it.c
